# Keil uVision project rtl87x3e_ota_demo.uvprojx, settings and files
target ota_demo_4M_bank0 (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: ota_demo
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 4M rtl87x3e all
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0  flash_4M_dualbank rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu --bss_threshold=0 --diag_suppress=177 --preinclude app_flags.h
  c include: ..\inc\rtl87x3e;..\..\ota_demo;..\..\..\..\inc\app;..\..\..\..\inc\os;..\..\..\..\inc\rtl87x3e\io;..\..\..\..\inc\stack;..\..\..\..\inc\rtl87x3e\platform;..\..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\..\inc\rtl87x3e\platform\console;..\..\..\..\inc\framework;..\..\..\..\inc\framework\sysm;..\..\..\..\inc\framework\audio;..\..\..\..\inc\framework\bt;..\..\..\..\inc\framework\remote;..\..\..\..\inc\framework\console;..\..\..\..\inc\rtl87x3e\hal;..\..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\..\inc\bluetooth\gap;..\..\..\..\inc\bluetooth\leaudio;..\..\..\..\inc\bluetooth\profile;..\..\..\..\inc\bluetooth\profile\server;..\..\..\..\inc\bluetooth\profile\client;..\..\..\..\inc\service;..\..\..\..\inc\service\gfps;..\..\..\..\inc\service\bisto;..\..\..\..\inc\service\xiaoai;..\..\..\..\inc\service\xiaowei;..\..\..\..\inc\service\ama;..\..\..\..\inc\service\teams;..\..\..\..\inc\service\teams\asp_device;..\..\..\..\inc\service\teams\hid;..\..\..\..\inc\service\teams\ble;..\..\..\..\src\mcu\module\led;..\..\..\..\inc\hal\power;..\..\..\..\src\mcu\legacy\spp_ota;..\..\..\..\src\mcu\rtl876x;..\..\..\..\src\mcu\module\vector;..\..\..\..\src\mcu\module\stream;..\..\..\..\src\mcu\usb\inc;..\..\..\..\src\ble\adv_mgr;..\..\..\..\src\ble\ble_conn_update;..\..\..\..\src\ble\gatt_client;..\..\..\..\src\debug;..\..\..\..\src\sample\ota_demo;..\..\..\..\bin\rtl87x3e\upperstack_stamp;..\..\..\..\bin\rtl87x3e\flash_map_config;..\..\..\..\inc\ble_mgr;..\..\..\..\inc\rtl87x3e\bluetooth\gap;..\..\..\..\inc\rtl87x3e\usb\class;..\..\..\..\inc\rtl87x3e\usb\composite;..\..\..\..\inc\rtl87x3e\hal\io;..\..\..\..\src\mcu\module\console\transport;..\..\..\..\src\sample\ota_demo\ha;..\..\..\..\inc\hal\platform;..\..\..\..\inc\hal\io;..\..\..\..\inc\platform;..\..\..\..\src\sample\common\app_ble_service;..\..\..\..\inc\rtl87x3e\os;..\..\..\..\inc\framework\sys;..\mdk
  asm misc: --cpreproc
  asm include: ..\..\..\..\inc\platform;..\inc\rtl87x3e_efe
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\cfg\rtl87x3e\rtl87x3e_ota_demo_bank0.sct
  link misc: --diag_suppress=L6314 --datacompressor off
  group include
    ../: config.h
    ../../../../src/sample/ota_demo/: app_flags.h
    ../../../../inc/rtl87x3e/platform/: rom_uuid.h
  group lib
    ../../../../bin/rtl87x3e/: ROM.lib hal_utils.lib upperstack_4M.lib ble_mgr.lib framework.lib
    ../../../../bin/rtl87x3e/framework/: sysm.lib remote.lib
    ../../../../bin/rtl87x3e/gap_lib/: gap_utils_4M.lib
  group cmsis
    ../../../../src/mcu/rtl87x3/arm/: startup_rtl87x3e.s
    ../../../../src/mcu/rtl87x3/: system_rtl87x3.c
  group app
    ../../../../src/sample/ota_demo/: app_main.c app_ota.c app_sdp.c app_gap.c app_spp.c app_report.c app_link_util.c app_cmd.c app_transfer.c app_ble_gap.c app_ble_service.c app_ble_common_adv.c
  group ble
    ../../../../src/sample/common/app_ble_service/: ota_service.c transmit_service.c
target ota_demo_4M_bank1 (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: ota_demo
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 4M rtl87x3e all
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank1  flash_4M_dualbank rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: as above
  c include: ..\inc\rtl87x3e;..\..\ota_demo;..\..\..\..\inc\app;..\..\..\..\inc\os;..\..\..\..\inc\rtl87x3e\io;..\..\..\..\inc\stack;..\..\..\..\inc\rtl87x3e\platform;..\..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\..\inc\rtl87x3e\platform\console;..\..\..\..\inc\framework;..\..\..\..\inc\framework\sysm;..\..\..\..\inc\framework\audio;..\..\..\..\inc\framework\bt;..\..\..\..\inc\framework\remote;..\..\..\..\inc\framework\console;..\..\..\..\inc\rtl87x3e\hal;..\..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\..\inc\bluetooth\gap;..\..\..\..\inc\bluetooth\leaudio;..\..\..\..\inc\bluetooth\profile;..\..\..\..\inc\bluetooth\profile\server;..\..\..\..\inc\bluetooth\profile\client;..\..\..\..\inc\service;..\..\..\..\inc\service\gfps;..\..\..\..\inc\service\bisto;..\..\..\..\inc\service\ama;..\..\..\..\src\mcu\module\led;..\..\..\..\inc\hal\power;..\..\..\..\src\mcu\legacy\spp_ota;..\..\..\..\src\mcu\rtl876x;..\..\..\..\src\mcu\module\vector;..\..\..\..\src\mcu\module\stream;..\..\..\..\src\mcu\usb\inc;..\..\..\..\src\ble\adv_mgr;..\..\..\..\src\ble\ble_conn_update;..\..\..\..\src\ble\gatt_client;..\..\..\..\src\debug;..\..\..\..\src\sample\ota_demo;..\..\..\..\bin\rtl87x3e\upperstack_stamp;..\..\..\..\bin\rtl87x3e\flash_map_config;..\..\..\..\inc\ble_mgr;..\..\..\..\inc\rtl87x3e\bluetooth\gap;..\..\..\..\inc\rtl87x3e\usb\class;..\..\..\..\inc\rtl87x3e\usb\composite;..\..\..\..\inc\rtl87x3e\hal\io;..\..\..\..\src\mcu\module\console\transport;..\..\..\..\src\sample\ota_demo\ha;..\..\..\..\inc\hal\platform;..\..\..\..\inc\hal\io;..\..\..\..\inc\platform;..\..\..\..\src\sample\common\app_ble_service;..\..\..\..\inc\rtl87x3e\os;..\..\..\..\inc\framework\sys;..\mdk
  asm misc: --cpreproc
  asm include: ..\..\..\..\inc\platform;..\inc\rtl87x3e_efe
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\cfg\rtl87x3e\rtl87x3e_ota_demo_bank1.sct
  link misc: --diag_suppress=L6314 --datacompressor off
target ota_demo_16M_bank0 (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: ota_demo
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 16M rtl87x3e all
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0  flash_16M_dualbank rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: as above
  c include: ..\inc\rtl87x3e;..\..\ota_demo;..\..\..\..\inc\app;..\..\..\..\inc\rtl87x3e\os;..\..\..\..\inc\rtl87x3e\io;..\..\..\..\inc\stack;..\..\..\..\inc\rtl87x3e\platform;..\..\..\..\inc\platform;..\..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\..\inc\rtl87x3e\platform\console;..\..\..\..\inc\framework;..\..\..\..\inc\framework\sys;..\..\..\..\inc\framework\audio;..\..\..\..\inc\framework\mmi;..\..\..\..\inc\framework\bt;..\..\..\..\inc\framework\remote;..\..\..\..\inc\framework\console;..\..\..\..\inc\rtl87x3e\hal;..\..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\..\inc\bluetooth\gap;..\..\..\..\inc\bluetooth\leaudio;..\..\..\..\inc\bluetooth\profile;..\..\..\..\inc\bluetooth\profile\server;..\..\..\..\inc\bluetooth\profile\client;..\..\..\..\inc\service;..\..\..\..\inc\service\gfps;..\..\..\..\inc\service\bisto;..\..\..\..\inc\service\xiaoai;..\..\..\..\inc\service\xiaowei;..\..\..\..\inc\service\ama;..\..\..\..\inc\service\teams;..\..\..\..\inc\service\teams\asp_device;..\..\..\..\inc\service\teams\hid;..\..\..\..\inc\service\teams\ble;..\..\..\..\src\mcu\module\led;..\..\..\..\inc\hal\power;..\..\..\..\src\mcu\legacy\spp_ota;..\..\..\..\src\mcu\rtl876x;..\..\..\..\src\mcu\module\vector;..\..\..\..\src\mcu\module\stream;..\..\..\..\src\mcu\usb\inc;..\..\..\..\src\ble\adv_mgr;..\..\..\..\src\ble\ble_conn_update;..\..\..\..\src\ble\gatt_client;..\..\..\..\src\debug;..\..\..\..\src\sample\ota_demo;..\..\..\..\bin\rtl87x3e\upperstack_stamp;..\..\..\..\bin\rtl87x3e\flash_map_config;..\..\..\..\inc\ble_mgr;..\..\..\..\inc\rtl87x3e\bluetooth\gap;..\..\..\..\inc\rtl87x3e\usb\class;..\..\..\..\inc\rtl87x3e\usb\composite;..\..\..\..\inc\rtl87x3e\hal\io;..\..\..\..\inc\hal\io;..\..\..\..\src\mcu\module\console\transport;..\..\..\..\src\sample\ota_demo\ha;..\..\..\..\inc\hal\platform;..\..\..\..\src\sample\common\app_ble_service;..\..\..\..\inc\rtl87x3e\os;..\..\..\..\inc\framework\sys;..\mdk
  asm misc: --cpreproc
  asm include: ..\inc\rtl87x3e_efe
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\cfg\rtl87x3e\rtl87x3e_ota_demo_bank0.sct
  link misc: --diag_suppress=L6314 --datacompressor off
target ota_demo_16M_bank1 (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: ota_demo
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 16M rtl87x3e all
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank1  flash_16M_dualbank rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: as above
  c include: ..\inc\rtl87x3e;..\..\ota_demo;..\..\..\..\inc\app;..\..\..\..\inc\rtl87x3e\os;..\..\..\..\inc\rtl87x3e\io;..\..\..\..\inc\stack;..\..\..\..\inc\rtl87x3e\platform;..\..\..\..\inc\platform;..\..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\..\inc\rtl87x3e\platform\console;..\..\..\..\inc\framework;..\..\..\..\inc\framework\sys;..\..\..\..\inc\framework\audio;..\..\..\..\inc\framework\mmi;..\..\..\..\inc\framework\bt;..\..\..\..\inc\framework\remote;..\..\..\..\inc\framework\console;..\..\..\..\inc\rtl87x3e\hal;..\..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\..\inc\bluetooth\gap;..\..\..\..\inc\bluetooth\leaudio;..\..\..\..\inc\bluetooth\profile;..\..\..\..\inc\bluetooth\profile\server;..\..\..\..\inc\bluetooth\profile\client;..\..\..\..\inc\service;..\..\..\..\inc\service\gfps;..\..\..\..\inc\service\bisto;..\..\..\..\inc\service\ama;..\..\..\..\src\mcu\module\led;..\..\..\..\inc\hal\power;..\..\..\..\src\mcu\legacy\spp_ota;..\..\..\..\src\mcu\rtl876x;..\..\..\..\src\mcu\module\vector;..\..\..\..\src\mcu\module\stream;..\..\..\..\src\mcu\usb\inc;..\..\..\..\src\ble\adv_mgr;..\..\..\..\src\ble\ble_conn_update;..\..\..\..\src\ble\gatt_client;..\..\..\..\src\debug;..\..\..\..\src\sample\ota_demo;..\..\..\..\bin\rtl87x3e\upperstack_stamp;..\..\..\..\bin\rtl87x3e\flash_map_config;..\..\..\..\inc\ble_mgr;..\..\..\..\inc\rtl87x3e\bluetooth\gap;..\..\..\..\inc\rtl87x3e\usb\class;..\..\..\..\inc\rtl87x3e\usb\composite;..\..\..\..\inc\rtl87x3e\hal\io;..\..\..\..\inc\hal\io;..\..\..\..\src\mcu\module\console\transport;..\..\..\..\src\sample\ota_demo\ha;..\..\..\..\inc\hal\platform;..\..\..\..\src\sample\common\app_ble_service;..\..\..\..\inc\framework\sys;..\..\..\..\inc\rtl87x3e\os;..\mdk
  asm misc: --cpreproc
  asm include: ..\inc\rtl87x3e_efe
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\cfg\rtl87x3e\rtl87x3e_ota_demo_bank1.sct
  link misc: --diag_suppress=L6314 --datacompressor off
