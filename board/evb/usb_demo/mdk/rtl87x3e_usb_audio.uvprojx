# Keil uVision project rtl87x3e_usb_audio.uvprojx, settings and files
target usb_audio_4M_dual_bank0 (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: usb_audio
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 4M "0" rtl87x3e all
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0  flash_4M_dualbank rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_RTL8763ESE = 1 CUSTOMIZED_TUYA_BLE_CONFIG_FILE="rtk_tuya_ble_config.h" CONFIG_SOC_SERIES_RTL8763E_V2 = 1 CONFIG_REALTEK_USB_AUDIO_ENABLE = 1
  c misc: --gnu --bss_threshold=0 --diag_suppress=177 --preinclude app_flags.h
  c include: ..\inc\rtl87x3e;..\mdk;..\..\usb_demo;..\..\..\..\inc\app;..\..\..\..\inc\rtl87x3e\os;..\..\..\..\inc\rtl87x3e\io;..\..\..\..\inc\stack;..\..\..\..\inc\rtl87x3e\platform;..\..\..\..\inc\platform;..\..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\..\inc\rtl87x3e\platform\console;..\..\..\..\inc\framework;..\..\..\..\inc\framework\sys;..\..\..\..\inc\framework\audio;..\..\..\..\inc\framework\mmi;..\..\..\..\inc\framework\bt;..\..\..\..\inc\framework\remote;..\..\..\..\inc\framework\console;..\..\..\..\inc\rtl87x3e\hal;..\..\..\..\inc\hal\power;..\..\..\..\src\mcu\rtl876x;..\..\..\..\bin\rtl87x3e\upperstack_stamp;..\..\..\..\bin\rtl87x3e\flash_map_config;..\..\..\..\src\mcu\usb\inc;..\..\..\..\inc\rtl87x3e\hal\io;..\..\..\..\inc\hal\io;..\..\..\..\inc\bluetooth\gap;..\..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\..\inc\rtl87x3e\bluetooth\gap;..\..\..\..\inc\usb\class;..\..\..\..\inc\usb\composite;..\..\..\..\src\sample\usb_demo;..\..\..\..\src\sample\usb_demo\usb;..\..\..\..\src\sample\usb_demo\usb\audio;..\..\..\..\src\sample\usb_demo\usb\hid;..\..\..\..\src\sample\usb_demo\usb_audio;..\..\..\..\inc\hal\platform;..\..\..\..\inc\usb
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\rtl87x3e_usb_audio.sct
  link misc: --diag_suppress=L6314 --datacompressor off
  group include
    ../: config.h
    ../../../../inc/rtl87x3e/platform/: rom_uuid.h
    ../../../../src/sample/usb_demo/: app_flags.h
  group lib
    ../../../../bin/rtl87x3e/: ROM.lib framework.lib hal_utils.lib upperstack_2M.lib upperstack_4M.lib gap_utils.lib usb.lib usb_hal.lib
    ../../../../bin/rtl87x3e/framework/: console.lib sysm.lib remote.lib
  group cmsis
    ../../../../src/mcu/rtl87x3/arm/: startup_rtl87x3e.s
    ../../../../src/mcu/rtl87x3/: system_rtl87x3.c
  group usb
    ../../../../src/sample/usb_demo/usb/audio/: usb_audio_stream.c usb_audio1.c
    ../../../../src/sample/usb_demo/usb/: usb_dev.c
    ../../../../src/sample/usb_demo/usb/hid/: usb_hid.c
  group usb_demo
    ../../../../src/sample/usb_demo/: app_main.c app_io_msg.c app_ipc.c app_usb.c
    ../../../../src/sample/usb_demo/usb_audio/: app_usb_audio.c app_usb_audio_mmi.c
target usb_audio_16M_dual_bank0 (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: usb_audio
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 16M "0" rtl87x3e all
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0  flash_16M_dualbank rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: as above
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\rtl87x3e_usb_audio.sct
  link misc: --diag_suppress=L6314 --datacompressor off
