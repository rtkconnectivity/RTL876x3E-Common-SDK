# Keil uVision project rtl87x3e_lea_cap_initiator.uvprojx, settings and files
target lea_cap_initiator_4M_bank0 (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: lea_cap_initiator
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 4M rtl87x3e all
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe" "#L" @L bank0 flash_4M_dualbank rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu --preinclude app_lea_cap_ini_flags.h --bss_threshold=0 --preinclude board.h
  c include: ..\..\lea_cap_initiator;..\..\..\..\src\sample\lea_samples\lea_cap_initiator;..\..\..\..\src\mcu\module\data_uart_cmd;..\..\..\..\inc\app;..\..\..\..\inc\bluetooth\gap;..\..\..\..\inc\rtl87x3e\os;..\..\..\..\inc\rtl87x3e\io;..\..\..\..\inc\rtl87x3e\platform;..\..\..\..\inc\platform;..\..\..\..\inc\bluetooth\profile;..\..\..\..\inc\bluetooth\profile\server;..\..\..\..\inc\bluetooth\profile\client;..\..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\..\inc\rtl87x3e\hal;..\..\..\..\src\mcu\rtl87x3;..\..\..\..\bin\rtl87x3e\upperstack_stamp;..\inc\rtl87x3e;..\..\..\..\bin\rtl87x3e\flash_map_config;..\..\..\..\inc\rtl87x3e\bluetooth\gap;..\..\..\..\inc\rtl87x3e\hal\io;..\..\..\..\inc\hal\io;..\..\..\..\inc\ble_mgr;..\..\..\..\inc\hal\platform;..\..\..\..\inc\bluetooth\leaudio;..\..\..\..\inc\framework\sys;..\..\..\..\src\ble\gatt_client;..\mdk
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\cfg\rtl87x3e\rtl87x3e_lea_cap_initiator_bank0.sct
  link misc: --diag_suppress=L6314 --datacompressor off
  group include
    ../../../../inc/rtl87x3e/platform/: rom_uuid.h
    ./: config.h
  group lib
    ../../../../bin/rtl87x3e/: gap_utils.lib ROM.lib upperstack_4M.lib hal_utils.lib ble_mgr.lib leaudio.lib
    ../../../../bin/rtl87x3e/framework/: sysm.lib
  group cmsis
    ../../../../src/mcu/rtl87x3/arm/: startup_rtl87x3e.s
    ../../../../src/mcu/rtl87x3/: system_rtl87x3.c
  group app
    ../../../../src/mcu/module/data_uart_cmd/: data_uart.c user_cmd_parse.c
    ../../../../src/ble/gatt_client/: bt_ext_ftl.c gattc_tbl_storage.c
    ../../../../src/sample/lea_samples/lea_cap_initiator/: app_lea_cap_ini_gap.c app_lea_cap_ini_main.c app_lea_cap_ini_user_cmd.c app_lea_cap_ini_profile.c app_lea_cap_ini_link.c app_lea_cap_ini_csis.c app_lea_cap_ini_scan.c app_lea_cap_ini_cap.c app_lea_cap_ini_bap.c app_lea_cap_ini_bap_bsrc.c app_lea_cap_ini_audio_data.c app_lea_cap_ini_mcp.c app_lea_cap_ini_ccp.c app_lea_cap_ini_ecfc.c
target lea_cap_initiator_16M_bank0 (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: lea_cap_initiator
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 16M rtl87x3e all
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe" "#L" @L bank0 flash_16M_dualbank rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: as above
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\cfg\rtl87x3e\rtl87x3e_lea_cap_initiator_bank0.sct
  link misc: --diag_suppress=L6314 --datacompressor off
