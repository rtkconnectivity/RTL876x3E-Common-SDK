# Keil uVision project rtl87x3e_bt_hid_demo.uvprojx, settings and files
target bt_hid_demo_1M_bank0 (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: bt_hid_demo
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 1M rtl87x3e bt_hid "0"
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0  flash_1M_dualbank rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_RTL8753EFE = 1
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\..\bt_hid_demo;..\inc\rtl87x3e;..\..\..\..\inc\rtl87x3e\platform;..\..\..\..\inc\platform;..\..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\..\inc\rtl87x3e\os;..\..\..\..\inc\bluetooth\profile;..\..\..\..\inc\bluetooth\gap;..\..\..\..\inc\app;..\..\..\..\inc\rtl87x3e\io;..\..\..\..\inc\rtl87x3e\hal;..\..\..\..\inc\rtl87x3e\hal\io;..\..\..\..\inc\hal\io;..\..\..\..\bin\rtl87x3e\upperstack_stamp;..\..\..\..\bin\rtl87x3e\flash_map_config;..\..\..\..\src\sample\bt_hid_demo;..\..\..\..\inc\framework\bt;..\..\..\..\inc\framework\remote;..\..\..\..\inc\framework\sys;..\..\..\..\inc\framework\audio;..\..\..\..\inc\framework\console;..\..\..\..\inc\rtl87x3e\bluetooth\gap;..\..\..\..\src\mcu\module\console\transport;..\..\..\..\inc\hal\platform;..\mdk
  asm misc: --cpreproc
  asm include: ..\inc\rtl87x3e
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\cfg\rtl87x3e\rtl87x3e_bt_hid_demo_bank0.sct
  link misc: --diag_suppress=L6314 --datacompressor off
  group include
    ../../../../inc/rtl87x3e/platform/: rom_uuid.h
    ../: config.h
  group lib
    ../../../../bin/rtl87x3e/: gap_utils.lib ROM.lib upperstack_2M.lib upperstack_4M.lib hal_utils.lib framework.lib
    ../../../../bin/rtl87x3e/framework/: console.lib sysm.lib remote.lib
  group cmsis
    ../../../../src/mcu/rtl87x3/arm/: startup_rtl87x3e.s
    ../../../../src/mcu/rtl87x3/: system_rtl87x3.c
  group app
    ../../../../src/mcu/module/console/transport/: console_uart.c
    ../../../../src/sample/bt_hid_demo/: app_dlps.c app_console_msg.c app_io_msg.c app_bt_hid_demo.c app_bt_hid_demo_console.c app_bt_hid_demo_gap.c app_bt_hid_demo_link.c app_bt_hid_demo_main.c
target bt_hid_demo_4M_bank0 (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: bt_hid_demo
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 4M rtl87x3e all "0"
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0  flash_4M_dualbank rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_RTL8753EFE = 1
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: as above
  asm misc: --cpreproc
  asm include: ..\inc\rtl87x3e
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\cfg\rtl87x3e\rtl87x3e_bt_hid_demo_bank0.sct
  link misc: --diag_suppress=L6314 --datacompressor off
target bt_hid_demo_16M_bank0 (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: bt_hid_demo
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 16M rtl87x3e all "0"
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0  flash_16M_dualbank rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_RTL8753EFE = 1
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: as above
  asm misc: --cpreproc
  asm include: ..\inc\rtl87x3e
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\cfg\rtl87x3e\rtl87x3e_bt_hid_demo_bank0.sct
  link misc: --diag_suppress=L6314 --datacompressor off
