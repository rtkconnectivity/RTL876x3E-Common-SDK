# Keil uVision project rtl87x3e_gui_demo.uvprojx, settings and files
target gui_demo_16M_bank0 (6220000::V6.22::.\ArmCompilerforEmbedded6.22)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: gui_demo +hex
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 16M "0" rtl87x3e
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0  flash_16M rtl87x3e
  c flags: Optim=5 uC99=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: PRE_UPPERSTACK=1 NOT_SUPPORT_UPPERSTACK CONFIG_SOC_SERIES_RTL8763E_V2=1 SUPPORT_ACCESS_SHM=1 OS_FREERTOS=1, RTL8763EP CONFIG_REALTEK_TARGET_RTL8763EWE_VP=1 CONFIG_REALTEK_TARGET_RTL8763EW_VC=0 CONFIG_REALTEK_TARGET_RTL8763EWE=0
  c misc: --include cmsis_armclang.h  --include gui_port_flags.h -Wno-switch -Wno-typedef-redefinition -Wno-macro-redefined
  c include: ..\..\..\inc\app;..\..\..\inc\rtl87x3e\platform;..\template;..\..\..\inc\rtl87x3e\os;..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\inc\rtl87x3e\io;..\..\..\src\mcu\rtl87x3;..\..\..\inc\rtl87x3e\hal\;.\inc\rtl87x3e;..\..\..\bin\rtl87x3e\flash_map_config;..\..\..\inc\rtl87x3e\hal\io;..\..\..\inc\hal\platform;..\..\..\inc\hal\io;..\..\..\inc\platform;..\..\..\inc\hal\power;..\..\..\inc\filesystem;..\..\..\src\sample\panel;..\..\..\bin\rtl87x3e\upperstack_stamp;..\..\..\src\mcu\module\lcdc_driver;..\..\..\src\mcu\module\lcd_module..\..\..\src\app\panel\application;..\..\..\src\app\panel\application\root_image;..\..\..\src\app\panel\armlibc;..\..\..\src\app\panel\gui_port;..\..\..\bin;..\..\..\inc;..\gui_demo;..\..\..\src\app\panel\application;..\..\..\src\mcu\module\lcd_module;..\..\..\src\app\panel\application\root_image\fs\romfs;..\..\..\src\app\panel\gui_benchmark;..\..\..\inc\rtl87x3e\platform\armclang;..\..\..\src\app\panel\gui_lib\include
  asm misc: --cpreproc
  asm include: ..\..\..\inc\platform;.\inc\rtl87x3e
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\rtl87x3e_gui_demo.sct
  link misc: --diag_suppress=L6314 --datacompressor off
  group include
    ../../../inc/rtl87x3e/platform/: rom_uuid.h
  group lib
    ../../../bin/rtl87x3e/: ROM.lib hal_utils.lib upperstack_4M.lib
    ../../../src/app/panel/gui_lib/rtl87x3e/: gui.lib
  group cmsis
    ../../../src/mcu/rtl87x3/: system_rtl87x3.c
    ../../../src/mcu/rtl87x3/arm/: startup_rtl87x3e_clang.c
  group io_driver
    ../../../src/mcu/io/rtl87x3e/: rtl876x_keyscan.c rtl876x_rtc.c
    ../../../src/mcu/io/: rtl876x_if8080.c
  group lcd_driver
    ../../../src/mcu/module/lcdc_driver/: lcd_sh8601z_454_qspi.c lcd_nt35510_480_8080.c lcd_sh8601z_454_qspi_1b.c lcd_st77916_320_385_qspi.c lcd_sh8601z_454_spi.c lcd_st7801_368_448_qspi.c
  group module
    ../../../src/mcu/module/lcd_module/: module_lcd_qspi.c module_lcd_8080.c module_lcd_qspi_1b.c module_lcd_spi.c module_touch_chsc6417.c module_psram.c module_touch_cst816t.c module_touch_gt9147.c module_touch_cst816d.c module_lcd_te.c module_touch_chsc5816.c
  group rtk_hal
    ../../../src/app/panel/application/: drv_lcd.c drv_touch.c
  group app
    ../../../src/app/panel/application/: main.c app_gui.c app_io_resource_init.c app_panel.c app_panel_init.c
  group realgui/port
    ../../../src/app/panel/gui_port/: gui_port_acc.c gui_port_dc.c gui_port_filesystem.c gui_port_ftl.c gui_port_indev.c gui_port_os.c
