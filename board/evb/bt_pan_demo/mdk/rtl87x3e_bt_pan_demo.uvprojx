# Keil uVision project rtl87x3e_bt_pan_demo.uvprojx, settings and files
target bt_pan_demo_4M_bank0 (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: bt_pan_demo
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 4M rtl87x3e all "0"
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0  flash_4M_dualbank rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_RTL8753EFE = 1 CONFIG_SOC_SERIES_RTL8763E
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\..\bt_pan_demo;..\inc\rtl87x3e;..\..\..\..\inc\rtl87x3e\platform;..\..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\..\inc\rtl87x3e\os;..\..\..\..\inc\bluetooth\profile;..\..\..\..\inc\bluetooth\gap;..\..\..\..\inc\app;..\..\..\..\inc\rtl87x3e\io;..\..\..\..\inc\rtl87x3e\hal;..\..\..\..\inc\rtl87x3e\hal\io;..\..\..\..\bin\rtl87x3e\upperstack_stamp;..\..\..\..\bin\rtl87x3e\flash_map_config;..\..\..\..\src\sample\bt_pan_demo;..\..\..\..\inc\framework\bt;..\..\..\..\inc\framework\remote;..\..\..\..\inc\framework\sys;..\..\..\..\inc\framework\audio;..\..\..\..\inc\framework\console;..\..\..\..\inc\rtl87x3e\bluetooth\gap;..\..\..\..\src\mcu\module\console\transport;..\..\..\..\inc\hal\platform;..\..\..\..\inc\hal\io;..\..\..\..\inc\platform;..\..\..\..\src\sample\lwip\src\include\;..\..\..\..\src\sample\lwip\src\arch;..\..\..\..\src\sample\mbedtls\include;..\..\..\..\src\sample\mbedtls\library;..\..\..\..\src\sample\mbedtls\tf-psa-crypto\core;..\..\..\..\src\sample\mbedtls\tf-psa-crypto\drivers\builtin\include;..\..\..\..\src\sample\mbedtls\tf-psa-crypto\include;..\..\..\..\src\sample\lwip\src;..\..\..\..\src\sample\lwip;..\mdk;..\..\..\..\src\sample\mbedtls\include\mbedtls
  asm misc: --cpreproc
  asm include: ..\inc\rtl87x3e
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\cfg\rtl87x3e\rtl87x3e_bt_pan_demo_bank0.sct
  link misc: --diag_suppress=L6314 --datacompressor off
  group include
    ../../../../inc/rtl87x3e/platform/: rom_uuid.h
    ../: config.h
  group lib
    ../../../../bin/rtl87x3e/: gap_utils.lib ROM.lib upperstack_2M.lib upperstack_4M.lib hal_utils.lib framework.lib lwip.lib mbedtls.lib
    ../../../../bin/rtl87x3e/framework/: console.lib sysm.lib remote.lib
  group cmsis
    ../../../../src/mcu/rtl87x3/arm/: startup_rtl87x3e.s
    ../../../../src/mcu/rtl87x3/: system_rtl87x3.c
  group app
    ../../../../src/mcu/module/console/transport/: console_uart.c
    ../../../../src/sample/bt_pan_demo/: app_dlps.c app_io_msg.c app_console_msg.c app_bt_pan_demo.c app_bt_pan_demo_console.c app_bt_pan_demo_gap.c app_bt_pan_demo_link.c app_bt_pan_demo_main.c
  group pan_test
    ../../../../src/sample/bt_pan_demo/pan_test/: http.c ping.c sem.c sockets.c
  group pan_test/https
    ../../../../src/sample/bt_pan_demo/pan_test/https/: https_demo.c mbedtls_port.c
target bt_pan_demo_16M_bank0 (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: bt_pan_demo
  BeforeMake: as above
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0  flash_16M_dualbank rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_RTL8753EFE = 1 CONFIG_SOC_SERIES_RTL8763E
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\..\bt_pan_demo;..\inc\rtl87x3e;..\..\..\..\inc\rtl87x3e\platform;..\..\..\..\inc\platform;..\..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\..\inc\rtl87x3e\os;..\..\..\..\inc\bluetooth\profile;..\..\..\..\inc\bluetooth\gap;..\..\..\..\inc\app;..\..\..\..\inc\rtl87x3e\io;..\..\..\..\inc\rtl87x3e\hal;..\..\..\..\inc\rtl87x3e\hal\io;..\..\..\..\inc\hal\io;..\..\..\..\bin\rtl87x3e\upperstack_stamp;..\..\..\..\bin\rtl87x3e\flash_map_config;..\..\..\..\src\sample\bt_pan_demo;..\..\..\..\inc\framework\bt;..\..\..\..\inc\framework\remote;..\..\..\..\inc\framework\sys;..\..\..\..\inc\framework\audio;..\..\..\..\inc\framework\console;..\..\..\..\inc\rtl87x3e\bluetooth\gap;..\..\..\..\src\mcu\module\console\transport;..\..\..\..\inc\hal\platform;..\..\..\..\src\sample\mbedtls\include;..\..\..\..\src\sample\mbedtls\library;..\..\..\..\src\sample\mbedtls\tf-psa-crypto\core;..\..\..\..\src\sample\mbedtls\tf-psa-crypto\drivers\builtin\include;..\..\..\..\src\sample\mbedtls\tf-psa-crypto\include;..\..\..\..\src\sample\lwip;..\..\..\..\src\sample\lwip\src;..\..\..\..\src\sample\lwip\src\arch;..\..\..\..\src\sample\lwip\src\include;..\mdk;..\..\..\..\src\sample\mbedtls\include\mbedtls
  asm misc: --cpreproc
  asm include: ..\inc\rtl87x3e
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\cfg\rtl87x3e\rtl87x3e_bt_pan_demo_bank0.sct
  link misc: --diag_suppress=L6314 --datacompressor off
