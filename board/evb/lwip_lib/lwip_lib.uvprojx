# Keil uVision project lwip_lib.uvprojx, settings and files
target lwip_rtl87x3e (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: lwip (library)
  AfterMake: cmd.exe /c lwip_lib_after_build.bat 3e&& echo %TIME%
  c flags: Optim=3 uC99=1 wLevel=2
  c define: GFPS_FEATURE_SUPPORT=1 GFPS_SASS_SUPPORT=1 GFPS_FINDER_SUPPORT=1 GFPS_LE_DEVICE_SUPPORT=1 GFPS_FEATURE_TEST_SUPPORT=0 TARGET_RTL8763E
  c misc: --gnu --bss_threshold=0
  c include: ..\..\..\src\sample\lwip\src\include;..\..\..\src\sample\lwip\src;..\..\..\src\sample\lwip\src\arch;..\..\..\inc\rtl87x3e\platform;..\..\..\inc\os;..\..\..\..\hal\inc\bb2;..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\inc\hal\io;..\..\..\..\hal\inc\bb2;..\..\..\inc\platform;..\..\..\inc\rtl87x3e\os
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6314 --datacompressor off
  group api
    ../../../src/sample/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group core
    ../../../src/sample/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../src/sample/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../src/sample/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group netif
    ../../../src/sample/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group arch
    ../../../src/sample/lwip/src/arch/: bnepif.c sys_arch.c
  group apps
    ../../../src/sample/lwip/src/apps/http/: http_client.c
    ../../../src/sample/lwip/contrib/apps/ping/: ping.c
