# Keil uVision project mbedtls.uvprojx, settings and files
target rtl87x3e (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: mbedtls +hex (library)
  AfterMake: cmd.exe /c mbedtls_after_build.bat 3e && echo %TIME%
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_SOC_SERIES_RTL8763E MBEDTLS_CONFIG_FILE="port/mbedtls_config.h"
  c misc: --gnu --bss_threshold=0
  c include: ..\..\..\..\inc\platform;..\..\..\..\inc\os;..\..\..\..\inc\framework\console;..\..\..\..\inc\rtl87x3e\platform;..\..\..\src\sample\mbedtls\include;..\..\..\src\sample\mbedtls;..\..\..\src\sample\mbedtls\include\library;..\..\..\src\sample\mbedtls\include\library\tf-psa-crypto;..\..\..\src\sample\mbedtls\tf-psa-crypto\core;..\..\..\src\sample\mbedtls\tf-psa-crypto\include;..\..\..\src\sample\mbedtls\tf-psa-crypto\include\psa;..\..\..\src\sample\mbedtls\tf-psa-crypto\drivers;..\..\..\src\sample\mbedtls\tf-psa-crypto\drivers\builtin;..\..\..\src\sample\mbedtls\tf-psa-crypto\drivers\builtin\include;..\..\..\src\sample\mbedtls\tf-psa-crypto\drivers\builtin\mbedtls;..\..\..\src\sample\mbedtls\tf-psa-crypto\drivers\builtin\src;..\..\..\src\sample\mbedtls\include\mbedtls;..\..\..\inc\rtl87x3e\io;..\..\..\inc\platform;..\..\..\inc\rtl87x3e\platform;..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\inc\rtl87x3e\io;..\..\..\inc\hal\io;..\..\..\src\sample\mbedtls\library;..\..\..\inc\rtl87x3e\os;..\..\..\inc\os;..\..\..\src\sample\mbedtls\port
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6314 --datacompressor off
  group library
    ../../../src/sample/mbedtls/library/: debug.c mps_reader.c mps_trace.c net_sockets.c pkcs7.c ssl_cache.c ssl_ciphersuites.c ssl_client.c ssl_cookie.c ssl_msg.c ssl_ticket.c ssl_tls.c ssl_tls12_client.c ssl_tls12_server.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_keys.c ssl_tls13_server.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write.c x509write_crt.c x509write_csr.c ssl_debug_helpers_generated.c aes.c aesce.c aesni.c aria.c asn1parse.c asn1write.c base64.c bignum.c bignum_core.c bignum_mod.c bignum_mod_raw.c block_cipher.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_curves_new.c entropy.c entropy_poll.c error.c gcm.c hkdf.c hmac_drbg.c lmots.c lms.c md.c md5.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c pem.c pk.c pk_ecc.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers_no_static.c psa_crypto_ecp.c psa_crypto_ffdh.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_pake.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c psa_util.c ripemd160.c rsa.c rsa_alt_helpers.c sha1.c sha3.c sha256.c sha512.c threading.c timing.c version.c version_features.c
  group port
    ../../../src/sample/mbedtls/port/: mbedtls_port.c
