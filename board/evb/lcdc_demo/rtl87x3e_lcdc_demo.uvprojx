# Keil uVision project rtl87x3e_lcdc_demo.uvprojx, settings and files
target lcdc_demo_16M_bank0 (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: lcdc_demo +hex
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 16M "0" rtl87x3e
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0  flash_16M rtl87x3e
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PRE_UPPERSTACK=1 NOT_SUPPORT_UPPERSTACK TARGET_RTL8753EFE = 1
  c misc: --gnu --bss_threshold=0
  c include: ..\..\..\inc\app;..\..\..\inc\rtl87x3e\platform;..\template;..\..\..\inc\os;..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\inc\rtl87x3e\io;..\..\..\src\mcu\rtl87x3;..\..\..\inc\rtl87x3e\hal\;.\inc\rtl87x3e;..\..\..\bin\rtl87x3e\flash_map_config;..\..\..\inc\rtl87x3e\hal\io;..\..\..\inc\hal\platform;..\..\..\inc\hal\io;..\..\..\inc\platform;..\..\..\inc\hal\power;..\..\..\src\sample\lcdc_demo;..\lcdc_demo;..\..\..\bin\rtl87x3e\upperstack_stamp;..\..\..\src\mcu\module\lcdc_driver;..\..\..\src\mcu\module\lcd_module;..\..\..\inc\rtl87x3e\os
  asm misc: --cpreproc
  asm include: ..\..\..\inc\platform;.\inc\rtl87x3e
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\rtl87x3e_lcdc_demo.sct
  link misc: --diag_suppress=L6314 --datacompressor off
  group include
    ../../../inc/rtl87x3e/platform/: rom_uuid.h
  group lib
    ../../../bin/rtl87x3e/: ROM.lib hal_utils.lib
  group cmsis
    ../../../src/mcu/rtl87x3/arm/: startup_rtl87x3e.s
    ../../../src/mcu/rtl87x3/: system_rtl87x3.c
  group io_driver
    ../../../src/mcu/io/: rtl876x_if8080.c
  group lcd_driver
    ../../../src/mcu/module/lcdc_driver/: lcd_sh8601z_454_qspi.c lcd_nt35510_480_8080.c lcd_sh8601z_454_qspi_1b.c lcd_st77916_320_385_qspi.c lcd_sh8601z_454_spi.c lcd_st7801_368_448_qspi.c
  group module
    ../../../src/mcu/module/lcd_module/: module_lcd_qspi.c module_lcd_8080.c module_lcd_qspi_1b.c module_lcd_spi.c module_lcd_te.c
  group app
    ../../../src/sample/lcdc_demo/: main.c app_task.c app_io_resource_init.c app_gui.c
