# Keil uVision project rtl87x3e_bt_audio_trx.uvprojx, settings and files
target bt_audio_trx_4M_lea_dual_bank0 (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: bt_audio_trx
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 4M rtl87x3e all
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0  flash_4M_dualbank rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_REALTEK_FILESYSTEM_EXFAT_SUPPORT=1
  c misc: --gnu --bss_threshold=0 --diag_suppress=177 --preinclude app_flags.h --preinclude app_lea_flags.h --preinclude app_gfps_flags.h --preinclude app_flags_customer.h --preinclude ble_audio_flags.h --preinclude app_findmy_flags.h
  c include: ..\..\..\..\inc\app;..\..\..\..\inc\stack;..\..\..\..\inc\rtl87x3e\os;..\..\..\..\inc\rtl87x3e\io;..\..\..\..\inc\rtl87x3e\platform;..\..\..\..\inc\platform;..\..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\..\inc\rtl87x3e\platform\console;..\..\..\..\inc\rtl87x3e\hal;..\..\..\..\inc\hal\power;..\..\..\..\inc\rtl87x3e\hal\io;..\..\..\..\inc\hal\io;..\..\..\..\inc\framework;..\..\..\..\inc\framework\sys;..\..\..\..\inc\framework\audio;..\..\..\..\inc\framework\mmi;..\..\..\..\inc\framework\bt;..\..\..\..\inc\framework\remote;..\..\..\..\inc\framework\console;..\..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\..\inc\bluetooth\gap;..\..\..\..\inc\bluetooth\leaudio;..\..\..\..\inc\bluetooth\profile;..\..\..\..\inc\bluetooth\profile\server;..\..\..\..\inc\ble_mgr\bond;..\..\..\..\inc\ble_mgr;..\..\..\..\inc\hal\platform;..\..\..\..\src\mcu\module\led;..\..\..\..\src\mcu\legacy\spp_ota;..\..\..\..\src\mcu\rtl876x;..\..\..\..\src\mcu\module\vector;..\..\..\..\src\mcu\module\stream;..\..\..\..\src\mcu\usb\inc;..\..\..\..\src\ble\adv_mgr;..\..\..\..\src\ble\ble_conn_update;..\..\..\..\src\ble\bt_gatt_client;..\..\..\..\src\ble\gatt_client;..\..\..\..\src\ble\bt_gatt_svc;..\..\..\..\src\debug;..\..\..\..\bin\rtl87x3e\upperstack_stamp;..\..\..\..\bin\rtl87x3e\flash_map_config;..\inc\rtl87x3e;..\..\bt_audio_trx;..\..\..\..\src\sample\bt_audio_trx;..\..\..\..\src\sample\bt_audio_trx\app;..\..\..\..\src\sample\bt_audio_trx\ble;..\..\..\..\src\sample\bt_audio_trx\bqb;..\..\..\..\src\sample\bt_audio_trx\bond;..\..\..\..\src\sample\bt_audio_trx\bredr;..\..\..\..\src\sample\bt_audio_trx\bt_audio;..\..\..\..\src\sample\bt_audio_trx\bt_common;..\..\..\..\src\sample\bt_audio_trx\cmd;..\..\..\..\src\sample\bt_audio_trx\app_customer;..\..\..\..\src\sample\bt_audio_trx\io;..\..\..\..\src\sample\bt_audio_trx\module;..\..\..\..\src\sample\bt_audio_trx\mp;..\..\..\..\src\sample\bt_audio_trx\ota;..\..\..\..\src\sample\bt_audio_trx\power;..\..\..\..\src\sample\bt_audio_trx\smart_pa;..\..\..\..\src\sample\bt_audio_trx\transfer_path;..\..\..\..\src\sample\bt_audio_trx\music_playback\audio_decode_stream;..\..\..\..\src\sample\bt_audio_trx\music_playback;..\..\..\..\src\sample\bt_audio_trx\lea_src;..\..\..\..\src\sample\bt_audio_trx\lea_snk;..\..\..\..\src\sample\bt_audio_trx\source_play;..\..\..\..\src\sample\common;..\..\..\..\src\sample\common\findmy;..\..\..\..\src\sample\common\findmy\fmna;..\..\..\..\src\sample\common\findmy\fmna\platform;..\..\..\..\src\sample\common\findmy\ble_platform;..\..\..\..\src\sample\common\findmy\ble_profile;..\..\..\..\inc\usb\bc12;..\..\..\..\inc\usb\class;..\..\..\..\inc\usb\composite;..\..\..\..\src\sample\bt_audio_trx\usb;..\..\..\..\src\sample\bt_audio_trx\usb\audio;..\..\..\..\src\sample\bt_audio_trx\usb\hid;..\..\..\..\src\sample\bt_audio_trx\uart;..\..\..\..\src\sample\bt_audio_trx\uart_dfu;..\..\..\..\src\sample\common\gfps;..\..\..\..\src\sample\bt_audio_trx\test;..\..\..\..\inc\service\gfps;..\..\..\..\inc\filesystem;..\..\..\..\inc\usb;..\..\..\..\src\sample\common\app_ble_service;..\..\..\..\src\sample\common\app_ble_client;..\..\..\..\src\mcu\usb\lib\class\mass_storage;..\..\..\..\src\sample\bt_audio_trx\usb\mass_storage;..\..\..\..\src\mcu\sd_mgr\sd_lib;..\..\..\..\src\mcu\sd_mgr\config;..\mdk;..\..\..\..\src\sample\mbedtls\include;..\..\..\..\src\sample\mbedtls\library;..\..\..\..\src\sample\mbedtls\tf-psa-crypto\core;..\..\..\..\src\sample\mbedtls\tf-psa-crypto\drivers\builtin\include;..\..\..\..\src\sample\mbedtls\tf-psa-crypto\include;..\..\..\..\src\sample\bt_audio_trx\app_gfps;..\..\..\..\src\sample\bt_audio_trx\app_findmy
  asm misc: --cpreproc
  asm include: ..\inc\rtl87x3e
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\cfg\rtl87x3e\rtl87x3e_bt_audio_trx_bank0.sct
  link misc: --diag_suppress=L6314 --datacompressor off
  group include
    ../../../../inc/rtl87x3e/platform/: rom_uuid.h
    ../: board.h config.h
    ../inc/rtl87x3e/: mem_config.h
    ../../../../src/sample/bt_audio_trx/app/: app_flags.h app_flags_customer.h
  group lib
    ../../../../bin/rtl87x3e/: gap_utils.lib ROM.lib framework.lib hal_utils.lib upperstack_4M.lib ble_mgr.lib leaudio.lib usb.lib gfps.lib filesystem.lib usb_hal.lib sd.lib mbedtls.lib
    ../../../../bin/rtl87x3e/framework/: console.lib sysm.lib remote.lib
    ../../../../src/sample/bt_audio_trx/panel/gui_lib/RTL8763E/: gui.lib
  group cmsis
    ../../../../src/mcu/rtl87x3/arm/: startup_rtl87x3e.s
    ../../../../src/mcu/rtl87x3/: system_rtl87x3.c
  group app
    ../../../../src/sample/bt_audio_trx/app/: app_cfg_nv.c app_cfg.c app_device.c app_io_msg.c app_ipc.c app_main.c app_mmi.c app_test.c app_transfer_cfg.c app_transfer.c app_data_capture_cs.c app_record.c app_one_wire_uart.c app_uart.c app_key_cfg.c app_key_gpio.c app_key_process.c
    ../../../../src/sample/bt_audio_trx/test/: app_power_test.c
  group ble
    ../../../../src/ble/profile/server/: bas.c dis.c
    ../../../../src/ble/gatt_client/: gattc_tbl_storage.c bt_ext_ftl.c
    ../../../../src/sample/bt_audio_trx/ble/: ams.c ancs.c app_ble_client.c app_ble_device.c app_ble_gap.c app_ble_rand_addr_mgr.c app_ble_service.c app_ble_common_adv.c app_ble_sc_key_derive.c app_le_transfer.c app_ble_cfg.c hids_kb.c app_ble_hid_device.c app_ble_hid_host.c
    ../../../../src/ble/bt_gatt_client/: hids_gatt_client.c bas_gatt_client.c ams_client.c dis_gatt_client.c ancs_gatt_client.c gaps_gatt_client.c
    ../../../../src/sample/common/app_ble_service/: ota_service.c transmit_service.c rtk_vendor_dis_gatt_svc.c
    ../../../../src/sample/common/app_ble_client/: transmit_gatt_client.c
    ../../../../src/sample/bt_audio_tri_dongle/ota_client/: app_dfu_ota_client.c dfu_gatt_client.c ota_gatt_client.c
    ../../../../src/sample/bt_audio_tri_dongle/: uwb_vendor_client.c
  group bond
    ../../../../src/sample/bt_audio_trx/bond/: app_bond.c ble_audio_bond.c
  group bqb
    ../../../../src/sample/bt_audio_trx/bqb/: bqb_cmd.c bqb_main.c
  group bredr
    ../../../../src/sample/bt_audio_trx/bredr/: app_a2dp_cfg.c app_a2dp.c app_avrcp_cfg.c app_avrcp.c app_bt_policy_cfg.c app_bt_policy.c app_bt_policy_api.c app_hfp_cfg.c app_hfp.c app_hfp_ag.c app_hid_cfg.c app_hid.c app_hid_host.c app_iap_cfg.c app_iap.c app_iap_rtk.c app_linkback.c app_map_cfg.c app_map.c app_multilink.c app_pbap_cfg.c app_pbap.c app_sdp.c app_sniff_mode_cs.c app_spp_cfg.c app_spp.c
  group bt_audio
    ../../../../src/sample/bt_audio_trx/bt_audio/: app_amp.c app_audio_tone_cfg.c app_audio_cfg.c app_audio_policy.c app_audio_route.c app_eq_cfg.c app_eq.c app_line_in.c eq_ext_ftl.c eq_utils.c app_eq_fitting.c
    ../../../../src/sample/common/: app_dsp_cfg.c app_sidetone.c app_nrec.c
  group bt_common
    ../../../../src/sample/bt_audio_trx/bt_common/: app_att.c app_gap.c app_link_util_cs.c
  group cmd
    ../../../../src/sample/bt_audio_trx/cmd/: app_cmd.c app_report.c cli_power_cmd.c app_cmd_ble.c app_rpt_ble.c app_cmd_br.c app_cmd_customized.c app_cmd_device.c app_cmd_general.c app_cmd_other.c app_charging_case_cmd.c app_cmd_ancs.c
  group console
    ../../../../src/sample/bt_audio_trx/app/: app_console.c
    ../../../../src/sample/bt_audio_trx/io/: app_console_msg.c
    ../../../../src/sample/bt_audio_trx/uart/: console_uart.c
  group app_customer
    ../../../../src/sample/bt_audio_trx/app_customer/: app_customer.c app_customer_cmd.c app_customer_audio_policy.c app_customer_bt.c
    ../../../../src/sample/bt_audio_trx/smart_pa/: aw_customer_driver_interface.c aw87390_driver_interface.c
  group module
    ../../../../src/mcu/module/vector/: vector.c
    ../../../../src/sample/bt_audio_trx/module/: app_util.c
    ../../../../src/mcu/module/stream/: iap_stream.c common_stream.c ble_stream.c spp_stream.c
    ../../../../src/mcu/module/lcd_module/: module_lcd_qspi.c module_psram.c module_touch_cst816t.c module_touch_cst816d.c module_lcd_te.c module_touch_chsc5816.c
    ../../../../src/mcu/module/lcdc_driver/: lcd_sh8601z_454_qspi.c lcd_st77916_320_385_qspi.c
  group mp
    ../../../../src/sample/bt_audio_trx/mp/: single_tone.c
  group ota
    ../../../../src/sample/bt_audio_trx/ota/: app_ota.c
  group power
    ../../../../src/sample/bt_audio_trx/power/: app_adc.c app_adp.c app_auto_power_off.c app_charger_cfg.c app_charger.c app_dlps.c rtk_charger.c
  group transfer_path
    ../../../../src/sample/bt_audio_trx/transfer_path/: app_a2dp_xmit_src.c app_pp_buffer.c app_sco_xmit_mgr.c app_spi_cmd.c app_spi_master.c app_spi_common.c app_spi_slave.c app_a2dp_xmit_lea.c app_a2dp_xmit_mgr.c
  group findmy
    ../../../../src/sample/common/findmy/: app_findmy.c app_findmy_ble.c app_findmy_task.c peer_manager.c fm-crypto.c kdf963.c custom_app.c
    ../../../../src/sample/common/findmy/fmna/: fmna_adv.c fmna_config_control_point.c fmna_connection.c fmna_crypto.c fmna_debug_control_point.c fmna_gatt.c fmna_motion_detection.c fmna_nfc.c fmna_nonowner_control_point.c fmna_paired_owner_control_point.c fmna_pairing_control_point.c fmna_state_machine.c fmna_version.c
    ../../../../src/sample/common/findmy/fmna/platform/: fmna_adv_platform.c fmna_battery_platform.c fmna_connection_platform.c fmna_gatt_platform.c fmna_malloc_platform.c fmna_motion_detection_platform.c fmna_nfc_platform.c fmna_peer_manager.c fmna_sound_platform.c fmna_timer_platform.c
    ../../../../src/sample/common/findmy/ble_platform/: platform_list.c
    ../../../../src/sample/common/findmy/ble_profile/: accessory_info_service.c findmy_network_service.c
    ../../../../src/ble/profile/server/: tps.c
  group gfps
    ../../../../src/sample/common/gfps/: app_ecc.c app_gfps.c app_gfps_account_key.c app_gfps_device.c app_gfps_finder.c app_gfps_finder_adv.c app_gfps_finder_test_internal.c app_gfps_link.c app_gfps_personalized_name.c app_gfps_msg.c app_dult.c app_dult_device.c app_dult_svc.c app_gfps_link_util.c app_gfps_timer.c app_gfps_rfc.c
    ../../../../src/sample/bt_audio_trx/app_gfps/: app_gfps_cfg.c
  group usb
    ../../../../src/sample/bt_audio_trx/usb/: app_usb.c app_usb_audio.c app_usb_hid.c usb_dev.c app_usb_cdc.c
    ../../../../src/sample/bt_audio_trx/usb/audio/: usb_audio_stream.c usb_audio1.c
    ../../../../src/sample/bt_audio_trx/usb/hid/: usb_hid.c
    ../../../../src/mcu/usb/instance/: usb_ms_disk.c
    ../../../../src/sample/bt_audio_trx/usb/mass_storage/: usb_ms.c
    ../../../../src/sample/bt_audio_trx/usb/cdc/: usb_cdc.c
  group music_playback
    ../../../../src/sample/bt_audio_trx/music_playback/: a2dp_enc_buffer.c a2dp_src_stream_ctrl.c app_music_ctrl.c playback_audio_file.c playback_stream_ctrl.c
    ../../../../src/sample/bt_audio_trx/music_playback/audio_decode_stream/: aac_decode.c audio_fs_decode.c mp3_decode.c
  group source_play
    ../../../../src/sample/bt_audio_trx/source_play/: app_src_play.c app_src_play_a2dp.c app_src_play_cmd.c app_src_play_hfp.c app_src_playback.c app_src_play_pipe.c
  group lea_src
    ../../../../src/sample/bt_audio_trx/lea_src/: app_lea_ini_audio_data.c app_lea_ini_bap.c app_lea_ini_bap_bsrc.c app_lea_ini_cap.c app_lea_ini_profile.c app_lea_ini_csis.c app_lea_ini_cmd.c app_lea_ini_scan.c app_lea_ini_conn_mgr.c app_lea_ini_ccp.c app_lea_ini_mcp.c
  group lea_snk
    ../../../../src/sample/bt_audio_trx/lea_snk/: app_lea_acc_adv.c app_lea_acc_broadcast_audio.c app_lea_acc_cmd.c app_lea_acc_pacs.c app_lea_acc_profile.c app_lea_acc_scan.c app_lea_acc_ascs.c app_lea_acc_ccp.c app_lea_acc_csis.c app_lea_acc_mcp.c app_lea_acc_vcs.c app_lea_acc_unicast_audio.c app_lea_acc_vol_policy.c app_lea_acc_mgr.c
  group gui
    ../../../../src/sample/bt_audio_trx/panel/app_gui_db/: app_panel_bredr_db.c app_panel_device_db.c app_panel_le_db.c app_panel_db_common.c
    ../../../../src/sample/bt_audio_trx/panel/app_gui_init/: app_gui.c app_io_resource_init.c app_panel_init.c app_gui_bt_policy.c
    ../../../../src/sample/bt_audio_trx/panel/app_gui_msg/: app_panel_bredr_msg.c app_panel_device_msg.c app_panel_le_msg.c app_panel_msg.c app_panel_msg_util.c
    ../../../../src/sample/bt_audio_trx/panel/app_gui_ui/: app_panel.c app_simple_speed_demo.c example_img.c
    ../../../../src/sample/bt_audio_trx/panel/app_module_port/: drv_lcd.c drv_touch.c
  group tri_dongle
    ../../../../src/sample/bt_audio_tri_dongle/: app_tri_dongle_cmd.c app_tri_dongle_mgr.c app_tri_dongle_scan.c app_tri_dongle_uac.c app_tri_dongle_usb_hid_ctrl.c app_tri_dongle_hid_desc_ext_ftl.c app_tri_dongle_bond_manager.c app_tri_dongle_bond_mgr_ext_ftl.c app_tri_dongle_spi.c app_tri_dongle_media.c app_tri_dongle_volume.c app_tri_dongle_lea.c app_tri_dongle_telephony.c app_cfu_passthrough_ota.c
  group uart_dfu
    ../../../../src/sample/bt_audio_trx/uart_dfu/: app_uart_dfu.c
  group cfu
    ../../../../src/sample/common/: app_common_cfu.c app_cfu_transfer.c
  group update_file
    ../../../../src/sample/bt_audio_trx/update_file/: app_trans_update_file.c trans_update_file_service.c
  group realgui/port
    ../../../../src/sample/bt_audio_trx/panel/app_gui_port/: gui_port_acc.c gui_port_dc.c gui_port_filesystem.c gui_port_indev.c gui_port_os.c gui_port_ftl.c
  group uwb/nxp
    ../../../../src/sample/bt_audio_tri_dongle/uwb_nxp/: AppCallbacks.c demo_ranging_controlee.c demo_ranging_controller.c nxp_uwb_hal.c nxp_uwb_task.c
    ../../../../src/sample/bt_audio_tri_dongle/uwb_nxp/common/: AppRecovery.c AppStateManagement.c Demo_Common_Config.c
    ../../../../src/sample/bt_audio_tri_dongle/uwb_nxp/osal/: phOsalUwb_FreeRTOS.c phOsalUwb_Queue_FreeRTOS.c phOsalUwb_Thread_FreeRTOS.c phOsalUwb_Timer_FreeRTOS.c
    ../../../../src/sample/bt_audio_tri_dongle/uwb_nxp_lib/export/lib/mdk/: uwb_nxp_sr150.lib
target bt_audio_trx_4M_lea_dual_bank1 (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: bt_audio_trx
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 4M rtl87x3e all
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank1  flash_4M_dualbank rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_REALTEK_FILESYSTEM_EXFAT_SUPPORT=1
  c misc: --gnu --bss_threshold=0 --diag_suppress=177 --preinclude app_flags.h --preinclude app_lea_flags.h  --preinclude app_gfps_flags.h  --preinclude app_flags_customer.h --preinclude ble_audio_flags.h  --preinclude app_findmy_flags.h
  c include: ..\..\..\..\inc\app;..\..\..\..\inc\stack;..\..\..\..\inc\rtl87x3e\os;..\..\..\..\inc\rtl87x3e\io;..\..\..\..\inc\rtl87x3e\platform;..\..\..\..\inc\platform;..\..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\..\inc\rtl87x3e\platform\console;..\..\..\..\inc\rtl87x3e\hal;..\..\..\..\inc\hal\power;..\..\..\..\inc\rtl87x3e\hal\io;..\..\..\..\inc\hal\io;..\..\..\..\inc\framework;..\..\..\..\inc\framework\sys;..\..\..\..\inc\framework\audio;..\..\..\..\inc\framework\mmi;..\..\..\..\inc\framework\bt;..\..\..\..\inc\framework\remote;..\..\..\..\inc\framework\console;..\..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\..\inc\bluetooth\gap;..\..\..\..\inc\bluetooth\leaudio;..\..\..\..\inc\bluetooth\profile;..\..\..\..\inc\bluetooth\profile\server;..\..\..\..\inc\ble_mgr\bond;..\..\..\..\inc\ble_mgr;..\..\..\..\inc\hal\platform;..\..\..\..\src\mcu\module\led;..\..\..\..\src\mcu\legacy\spp_ota;..\..\..\..\src\mcu\rtl876x;..\..\..\..\src\mcu\module\vector;..\..\..\..\src\mcu\module\stream;..\..\..\..\src\mcu\usb\inc;..\..\..\..\src\ble\adv_mgr;..\..\..\..\src\ble\ble_conn_update;..\..\..\..\src\ble\bt_gatt_client;..\..\..\..\src\ble\gatt_client;..\..\..\..\src\ble\bt_gatt_svc;..\..\..\..\src\debug;..\..\..\..\bin\rtl87x3e\upperstack_stamp;..\..\..\..\bin\rtl87x3e\flash_map_config;..\inc\rtl87x3e;..\..\bt_audio_trx;..\..\..\..\src\sample\bt_audio_trx;..\..\..\..\src\sample\bt_audio_trx\app;..\..\..\..\src\sample\bt_audio_trx\ble;..\..\..\..\src\sample\bt_audio_trx\bqb;..\..\..\..\src\sample\bt_audio_trx\bond;..\..\..\..\src\sample\bt_audio_trx\bredr;..\..\..\..\src\sample\bt_audio_trx\bt_audio;..\..\..\..\src\sample\bt_audio_trx\bt_common;..\..\..\..\src\sample\bt_audio_trx\cmd;..\..\..\..\src\sample\bt_audio_trx\console;..\..\..\..\src\sample\bt_audio_trx\app_customer;..\..\..\..\src\sample\bt_audio_trx\io;..\..\..\..\src\sample\bt_audio_trx\module;..\..\..\..\src\sample\bt_audio_trx\mp;..\..\..\..\src\sample\bt_audio_trx\ota;..\..\..\..\src\sample\bt_audio_trx\power;..\..\..\..\src\sample\bt_audio_trx\smart_pa;..\..\..\..\src\sample\bt_audio_trx\transfer_path;..\..\..\..\src\sample\bt_audio_trx\music_playback\audio_decode_stream;..\..\..\..\src\sample\bt_audio_trx\music_playback;..\..\..\..\src\sample\bt_audio_trx\lea_src;..\..\..\..\src\sample\bt_audio_trx\lea_snk;..\..\..\..\src\sample\bt_audio_trx\source_play;..\..\..\..\src\sample\common;..\..\..\..\src\sample\common\findmy;..\..\..\..\src\sample\common\findmy\fmna;..\..\..\..\src\sample\common\findmy\fmna\platform;..\..\..\..\src\sample\common\findmy\ble_platform;..\..\..\..\src\sample\common\findmy\ble_profile;..\..\..\..\inc\usb\bc12;..\..\..\..\inc\usb\class;..\..\..\..\inc\usb\composite;..\..\..\..\src\sample\bt_audio_trx\usb;..\..\..\..\src\sample\bt_audio_trx\usb\audio;..\..\..\..\src\sample\bt_audio_trx\usb\hid;..\..\..\..\src\sample\bt_audio_trx\uart;..\..\..\..\src\sample\bt_audio_trx\uart_dfu;..\..\..\..\src\sample\bt_audio_trx\test;..\..\..\..\inc\service\gfps;..\..\..\..\src\sample\common\gfps;..\..\..\..\inc\filesystem;..\..\..\..\inc\usb;..\..\..\..\src\sample\common\app_ble_service;..\..\..\..\src\sample\common\app_ble_client;..\..\..\..\src\mcu\usb\lib\class\mass_storage;..\..\..\..\src\sample\bt_audio_trx\usb\mass_storage;..\..\..\..\src\mcu\sd_mgr\sd_lib;..\..\..\..\src\mcu\sd_mgr\config;..\mdk;..\..\..\..\src\sample\mbedtls\include;..\..\..\..\src\sample\mbedtls\library;..\..\..\..\src\sample\mbedtls\tf-psa-crypto\core;..\..\..\..\src\sample\mbedtls\tf-psa-crypto\drivers\builtin\include;..\..\..\..\src\sample\mbedtls\tf-psa-crypto\include;..\..\..\..\src\sample\bt_audio_trx\app_gfps;..\..\..\..\src\sample\bt_audio_trx\app_findmy
  asm misc: --cpreproc
  asm include: ..\inc\rtl87x3e
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\cfg\rtl87x3e\rtl87x3e_bt_audio_trx_bank1.sct
  link misc: --diag_suppress=L6314 --datacompressor off
target bt_audio_trx_16M_lea_dual_bank0 (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: bt_audio_trx
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 16M rtl87x3e all
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0  flash_16M_dualbank rtl87x3e
  c flags: uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CONFIG_REALTEK_TARGET_RTL8763EWE_VP=1 CONFIG_REALTEK_TARGET_RTL8763EW_VC=0 CONFIG_REALTEK_TARGET_RTL8763EWE=0 CONFIG_REALTEK_FILESYSTEM_EXFAT_SUPPORT=1
  c misc: --gnu --bss_threshold=0 --diag_suppress=177 --preinclude app_flags.h --preinclude app_lea_flags.h  --preinclude app_gfps_flags.h  --preinclude app_flags_customer.h --preinclude ble_audio_flags.h --reduce_paths --preinclude gui_port_flags.h  --preinclude app_findmy_flags.h
  c include: ..\..\..\..\inc\app;..\..\..\..\inc\stack;..\..\..\..\inc\rtl87x3e\os;..\..\..\..\inc\rtl87x3e\io;..\..\..\..\inc\rtl87x3e\platform;..\..\..\..\inc\platform;..\..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\..\inc\rtl87x3e\platform\console;..\..\..\..\inc\rtl87x3e\hal;..\..\..\..\inc\hal\power;..\..\..\..\inc\rtl87x3e\hal\io;..\..\..\..\inc\hal\io;..\..\..\..\inc\framework;..\..\..\..\inc\framework\sys;..\..\..\..\inc\framework\audio;..\..\..\..\inc\framework\mmi;..\..\..\..\inc\framework\bt;..\..\..\..\inc\framework\remote;..\..\..\..\inc\framework\console;..\..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\..\inc\bluetooth\gap;..\..\..\..\inc\bluetooth\leaudio;..\..\..\..\inc\bluetooth\profile;..\..\..\..\inc\bluetooth\profile\server;..\..\..\..\inc\ble_mgr\bond;..\..\..\..\inc\ble_mgr;..\..\..\..\inc\hal\platform;..\..\..\..\src\mcu\module\led;..\..\..\..\src\mcu\legacy\spp_ota;..\..\..\..\src\mcu\rtl876x;..\..\..\..\src\mcu\module\vector;..\..\..\..\src\mcu\module\stream;..\..\..\..\src\mcu\usb\inc;..\..\..\..\src\ble\adv_mgr;..\..\..\..\src\ble\ble_conn_update;..\..\..\..\src\ble\bt_gatt_client;..\..\..\..\src\ble\gatt_client;..\..\..\..\src\ble\bt_gatt_svc;..\..\..\..\src\debug;..\..\..\..\bin\rtl87x3e\upperstack_stamp;..\..\..\..\bin\rtl87x3e\flash_map_config;..\inc\rtl87x3e;..\..\bt_audio_trx;..\..\..\..\src\sample\bt_audio_trx;..\..\..\..\src\sample\bt_audio_trx\app;..\..\..\..\src\sample\bt_audio_trx\ble;..\..\..\..\src\sample\bt_audio_trx\bqb;..\..\..\..\src\sample\bt_audio_trx\bond;..\..\..\..\src\sample\bt_audio_trx\bredr;..\..\..\..\src\sample\bt_audio_trx\bt_audio;..\..\..\..\src\sample\bt_audio_trx\bt_common;..\..\..\..\src\sample\bt_audio_trx\cmd;..\..\..\..\src\sample\bt_audio_trx\app_customer;..\..\..\..\src\sample\bt_audio_trx\io;..\..\..\..\src\sample\bt_audio_trx\module;..\..\..\..\src\sample\bt_audio_trx\mp;..\..\..\..\src\sample\bt_audio_trx\ota;..\..\..\..\src\sample\bt_audio_trx\power;..\..\..\..\src\sample\bt_audio_trx\smart_pa;..\..\..\..\src\sample\bt_audio_trx\transfer_path;..\..\..\..\src\sample\bt_audio_trx\music_playback\audio_decode_stream;..\..\..\..\src\sample\bt_audio_trx\music_playback;..\..\..\..\src\sample\bt_audio_trx\lea_src;..\..\..\..\src\sample\bt_audio_trx\lea_snk;..\..\..\..\src\sample\bt_audio_trx\source_play;..\..\..\..\src\sample\common;..\..\..\..\src\sample\common\findmy;..\..\..\..\src\sample\common\findmy\fmna;..\..\..\..\src\sample\common\findmy\fmna\platform;..\..\..\..\src\sample\common\findmy\ble_platform;..\..\..\..\src\sample\common\findmy\ble_profile;..\..\..\..\inc\usb\bc12;..\..\..\..\inc\usb\class;..\..\..\..\inc\usb\composite;..\..\..\..\src\sample\bt_audio_trx\usb;..\..\..\..\src\sample\bt_audio_trx\usb\audio;..\..\..\..\src\sample\bt_audio_trx\usb\hid;..\..\..\..\src\sample\bt_audio_trx\uart;..\..\..\..\src\sample\bt_audio_trx\uart_dfu;..\..\..\..\src\mcu\module\lcd_module;..\..\..\..\src\mcu\module\lcdc_driver;..\..\..\..\src\sample\bt_audio_trx\panel\user_data\RTL87x3e;..\..\..\..\src\sample\bt_audio_trx\panel\app_gui_db;..\..\..\..\src\sample\bt_audio_trx\panel\app_gui_init;..\..\..\..\src\sample\bt_audio_trx\panel\app_gui_msg;..\..\..\..\src\sample\bt_audio_trx\panel\app_gui_port;..\..\..\..\src\sample\bt_audio_trx\panel\app_gui_ui;..\..\..\..\src\sample\bt_audio_trx\panel\app_module_port;..\..\..\..\src\sample\common\gfps;..\..\..\..\src\sample\bt_audio_trx\test;..\..\..\..\inc\service\gfps;..\..\..\..\inc\filesystem;..\..\..\..\inc\usb;..\..\..\..\src\sample\bt_audio_trx\usb\mass_storage;..\..\..\..\src\mcu\usb\lib\class\mass_storage;..\..\..\..\src\mcu\sd_mgr\sd_lib;..\..\..\..\src\mcu\sd_mgr\config;..\..\..\..\src\sample\common\app_ble_service;..\..\..\..\src\sample\common\app_ble_client;..\mdk;..\..\..\..\src\sample\bt_audio_trx\update_file;..\..\..\..\src\sample\mbedtls\include;..\..\..\..\src\sample\mbedtls\library;..\..\..\..\src\sample\mbedtls\tf-psa-crypto\core;..\..\..\..\src\sample\mbedtls\tf-psa-crypto\drivers\builtin\include;..\..\..\..\src\sample\mbedtls\tf-psa-crypto\include;..\..\..\..\src\sample\bt_audio_trx\app_gfps;..\..\..\..\src\sample\bt_audio_trx\app_findmy;..\..\..\..\src\sample\bt_audio_trx\panel\gui_lib\include
  asm misc: --cpreproc
  asm include: ..\inc\rtl87x3e
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\cfg\rtl87x3e\rtl87x3e_bt_audio_trx_bank0.sct
  link misc: --diag_suppress=L6314 --datacompressor off
target bt_audio_trx_16M_lea_dual_bank1 (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: bt_audio_trx
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 16M rtl87x3e all
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank1  flash_16M_dualbank rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: as above
  c include: as above
  asm misc: --cpreproc
  asm include: ..\inc\rtl87x3e
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\cfg\rtl87x3e\rtl87x3e_bt_audio_trx_bank1.sct
  link misc: --diag_suppress=L6314 --datacompressor off
